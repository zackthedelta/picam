# Build and package the GStreamer libcamerasrc plugin.
PACKAGECONFIG:append = " gst"
