# Needed by the default RTSP pipeline's x264enc element.
PACKAGECONFIG:append = " x264"
